SRCDATE = "20210329"

require abcom-recovery.inc

SRC_URI[md5sum] = "74cb1c72df1e03cc9667f571550a2037"
SRC_URI[sha256sum] = "ed35cdfb2d5c83fa8df2fcc7a42e2b5103b62119de670ffbfdedaf221d86e070"

COMPATIBLE_MACHINE = "pulse4k"
