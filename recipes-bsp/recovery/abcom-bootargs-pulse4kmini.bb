SRCDATE = "20221130"

require abcom-bootargs.inc

SRC_URI[md5sum] = "a9d53d19233ca3ee0aa97bc2c258cb6d"
SRC_URI[sha256sum] = "8477fddc404aadc5728ba24f6cf18069dbe4edc8ab475bde0921437efdc5183a"

COMPATIBLE_MACHINE = "pulse4kmini"
