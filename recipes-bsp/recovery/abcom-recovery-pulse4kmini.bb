SRCDATE = "20221130"

require abcom-recovery.inc

SRC_URI[md5sum] = "102aeb9cf23a5b2cd5b75966d87268b6"
SRC_URI[sha256sum] = "a7341dc6d7e8a4e97bc65cedf1554eca4d2b24498890dc9ae4fd75faa1184704"

COMPATIBLE_MACHINE = "pulse4kmini"
