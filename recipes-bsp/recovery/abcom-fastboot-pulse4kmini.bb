SRCDATE = "20221130"

require abcom-fastboot.inc

SRC_URI[md5sum] = "48860593ce9eb9a185a90e9355707505"
SRC_URI[sha256sum] = "0496d025ac1bb2fc888ae781b32bb6bbf7cddc80021d81c9ef9c98f1d9db1ebe"

COMPATIBLE_MACHINE = "pulse4kmini"
