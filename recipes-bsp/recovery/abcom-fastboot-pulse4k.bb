SRCDATE = "20221130"

require abcom-fastboot.inc

SRC_URI[md5sum] = "86ba009a58de9775267713a86b09a059"
SRC_URI[sha256sum] = "43670e9150639f2f60e8434040bb245c0730aeca983303cf4c9cb370d3eb220b"

COMPATIBLE_MACHINE = "pulse4k"
