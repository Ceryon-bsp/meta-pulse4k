SRCDATE = "20221330"

require abcom-bootargs.inc

SRC_URI[md5sum] = "fd41dcf5d8d1531692c7aacb7274c105"
SRC_URI[sha256sum] = "ae2b4b245d45e18e9310d9dfd9ebb8d61755ea3361c74db0e11a52e0e93c4bc9"

COMPATIBLE_MACHINE = "pulse4k"
