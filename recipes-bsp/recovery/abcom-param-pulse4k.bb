SRCDATE = "20210329"

require abcom-param.inc

SRC_URI[md5sum] = "cdbdf78726e1c334f5d43701689a5553"
SRC_URI[sha256sum] = "b4b40906d7594c5ac49fa5fdc6b7919d6485ec133aa59497eb6971b1083fc9a4"

COMPATIBLE_MACHINE = "pulse4k"
